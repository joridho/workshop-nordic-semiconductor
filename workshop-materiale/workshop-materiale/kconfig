## workshop-materiale/workshop-materiale/kconfig
```kconfig
source "Kconfig.zephyr"

config BLINK
	bool "Enable my function"
	default n

config MAIN
	bool "Enable my function"
	default y
```
